## patches/wrappers/curl/Kconfig
```kconfig
config UTILS_CURL
	bool "curl"
	default n

if UTILS_CURL

config LIB_CURL
	bool "curl library"
	default y

endif
```
